## ovo/ovo/Kconfig
```kconfig
config OVO
    tristate "ovo driver"
    default m
    help
      OVO kernel memory driver
```
